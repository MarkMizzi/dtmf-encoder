# Keil uVision project assignment.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: SignalGenerator
  c flags: Optim=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/: adc.c comparator.c dac.c gpio.c i2c.c uart.c adc.h comparator.h dac.h gpio.h i2c.h platform.h uart.h
  group src
    ./src/: main.c dac_interrupt.c dac_interrupt.h dtmf_symbols.h queue.h timer.h timer.c queue.s lcd.c lcd.h delay.h delay.c keypad.c keypad.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
