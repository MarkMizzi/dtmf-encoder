# Keil uVision project assignments.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.1
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: assignments
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c queue.s queue.h dtmf_symbols.h dac_interrupt.c dac_interrupt.h
    ./drivers/: dac.c dac.h platform.h timer.h timer.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
